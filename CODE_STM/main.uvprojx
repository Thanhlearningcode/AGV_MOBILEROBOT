# Keil uVision project main.uvprojx, settings and files
target Src (6140000::V6.14::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: main.c test.txt test.cpp
  group Communication
    ./: Uart1.c Uart1.h Uart2.c Uart2.h Spi1.h Spi1.c Spi2.h Spi2.c I2C1.c I2C1.h
  group I/O
    ./: Dio.c Dio.h Exti.c Exti.h
  group Module
    ./: HSCR04.h HSCR04.c Lcd1602.c Lcd1602.h BNO055.c BNO055.h BTS7960.h BTS7960.c
  group Control System
    ./: Motor.c Motor.h Rcc.c Rcc.h Encoder.c Encoder.h
  group Os
    ./: Kernel.h Kernel.c Kernel.s Systick.h Systick.c
  group ROS
    ./: STM32Hardware.h ros.h mainpp.h main.h node_handle.h time.h std_msgs.h msg.h duration.h TopicInfo.h Log.h RequestParam.h publisher.h subscriber.h service_server.h service_client.h Int16.h Float64.h Int32.h Twist.h Vector3.h
target Inc (6140000::V6.14::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: main +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\main
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.6.0, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
